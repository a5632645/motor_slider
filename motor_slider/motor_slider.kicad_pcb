# Repository a5632645/motor_slider

File readme.md (part):

# motor_slider
8个电动推子与MIDI CC的联动**原型机**测试

> [!NOTE]
> 本存储库含有大量AI生成内容，如果你不喜欢AI，请立刻返回

## 功能
8个电动推子，根据DAW MIDI CC移动位置，也能将电位器位置通过MIDI CC上传到DAW，两个操作不允许发生在同一时间，也不会进行抢占操作    
有7个推子含有原生PWM控制，另一个使用TIM+DMA写GPIO的形式模拟PWM  
电机控制器在小范围移动会产生可听的来回移动噪声  
MIDI CC目前固定为CC0~CC7  

## 额外内容
[购买电动线性电位器](https://item.taobao.com/item.htm?id=904405285742)

> 你说外壳，建议自己设计

> [!NOTE]
> 接下来的面板使用M3螺丝时选择平头的并且面板厚度不建议过厚，否则midi cc的范围会变成 2~124

立创面板源码，本人用的2.8mm(**别弄那么厚**)亚克力仍然会被压弯
```
{"type":"DOCHEAD"}||{"docType":"PANEL","client":"7755df130da93361","uuid":"ee90faf011b0bf49","updateTime":1781689268650,"version":"1781689268650"}|
{"type":"CANVAS","ticket":1,"id":"CANVAS"}||{"material":"acrylic","thickness":"2.0mm","print":"Ahead Side","craft":"Transparent","desc":"","coverColor":"white","width":"393mm","height":"579mm","originX":0,"originY":0,"orderWidth":"189.99mm","orderHeight":"151.89mm"}|
{"type":"POLY","ticket":2,"id":"e1584941ec573cd24"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":10,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,380.7879488188978,0,6.889763779527534,1338.7758897637789]}|
{"type":"POLY","ticket":3,"id":"e18f4a7329a3ff436"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":18,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,380.7849173228349,0,6.889763779527534,1811.2187007874004]}|
{"type":"POLY","ticket":4,"id":"ef68620ce32394071"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":11,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,468.1925748031497,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":5,"id":"ee57a8df2610ad1db"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":19,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,468.18954330708664,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":6,"id":"e849a7849dee4361d"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":12,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,555.5935748031496,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":7,"id":"e64859d853dfd7e9b"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":20,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,555.5905433070866,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":8,"id":"ecec94a499a380fba"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":13,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,642.9955748031495,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":9,"id":"ef3ef9754e380944a"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":21,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,642.9925433070866,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":10,"id":"e9294cab0f8b4fe10"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":14,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,730.3965748031495,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":11,"id":"ebccfad423ecd8b29"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":22,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,730.3935433070866,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":12,"id":"e99282393f4ec6fab"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":15,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,817.7985748031496,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":13,"id":"e8b75c9436c282883"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":23,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,817.7955433070866,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":14,"id":"e2a41bdb96d65d63a"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":16,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,905.2005748031496,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":15,"id":"e33940a38a94704ff"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":24,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,905.1975433070867,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":16,"id":"ee1f460c7b3ff9eb3"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":17,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,992.6015748031497,0,6.889763779527534,1338.779188976377]}|
{"type":"POLY","ticket":17,"id":"e3b649b0d4ee38bb5"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":25,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,992.5985433070867,0,6.889763779527534,1811.2219999999984]}|
{"type":"POLY","ticket":18,"id":"ec19dd633df9f9027"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":26,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,327.16507480314976,0,6.889763779527534,1850.7869291338563]}|
{"type":"POLY","ticket":19,"id":"e5c19595f2625c8ff"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":27,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,327.1644094488191,0,6.889763779527534,1306.3316220472423]}|
{"type":"POLY","ticket":20,"id":"e6e8d903b9c234424"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":28,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,1040.9346889763783,0,6.889763779527534,1306.3313228346442]}|
{"type":"POLY","ticket":21,"id":"e58a1011d351861f7"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["ELLIPSE",0,0,1,1,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":29,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[6.889763779527534,0,1040.9354921259842,0,6.889763779527534,1850.7872834645655]}|
{"type":"POLY","ticket":22,"id":"e03eb1e0feb6fb015"}||{"groupId":"0","layer":3,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":9,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[748,-2.343515398637612e-15,311.00000000000006,-3.210431588880691e-15,597.9999999999999,1874]}|
{"type":"POLY","ticket":23,"id":"e8425d0d29416879a"}||{"groupId":"0","layer":1,"rotation":0,"strokeWidth":3.937007874015748,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":false,"displayStroke":true,"locked":false,"zIndex":1,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[67.71653543307086,0,346.92671259842524,0,576.771653543307,1863.3824173228334]}|
{"type":"POLY","ticket":24,"id":"ed294a9686753e663"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":30,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[9.842519685039406,0,375.8628543307085,0,433.07086614173227,1791.5328503936992]}|
{"type":"POLY","ticket":25,"id":"ef3a6cacf585e59a6"}||{"groupId":"0","layer":1,"rotation":0,"strokeWidth":3.937007874015748,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":false,"displayStroke":true,"locked":false,"zIndex":2,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[67.71653543307086,0,434.3313385826771,0,576.771653543307,1863.3857165354316]}|
{"type":"POLY","ticket":26,"id":"e583333e3c7230aa1"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":31,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[9.842519685039406,0,463.2674803149603,0,433.07086614173227,1791.5361496062974]}|
{"type":"POLY","ticket":27,"id":"eaf03c847e17b207d"}||{"groupId":"0","layer":1,"rotation":0,"strokeWidth":3.937007874015748,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":false,"displayStroke":true,"locked":false,"zIndex":3,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[67.71653543307086,0,521.7323385826771,0,576.771653543307,1863.3857165354316]}|
{"type":"POLY","ticket":28,"id":"e2db45f8716f7ab01"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":32,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[9.842519685039406,0,550.6684803149603,0,433.07086614173227,1791.5361496062974]}|
{"type":"POLY","ticket":29,"id":"eb4fa830be97bb013"}||{"groupId":"0","layer":1,"rotation":0,"strokeWidth":3.937007874015748,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":false,"displayStroke":true,"locked":false,"zIndex":4,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[67.71653543307086,0,609.1343385826772,0,576.771653543307,1863.3857165354316]}|
{"type":"POLY","ticket":30,"id":"e0a4fecc1b48feb2d"}||{"groupId":"0","layer":4,"rotation":0,"strokeWidth":0,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":true,"displayStroke":true,"locked":false,"zIndex":33,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[9.842519685039406,0,638.0704803149604,0,433.07086614173227,1791.5361496062974]}|
{"type":"POLY","ticket":31,"id":"ea5e9c516e7580935"}||{"groupId":"0","layer":1,"rotation":0,"strokeWidth":3.937007874015748,"strokeStyle":"SOLID","strokeColor":"#000000","fillColor":"#000000","opacity":1,"autoClose":false,"ploys":[["R",0,0,1,1,0,0,0,0]],"displayFill":false,"displayStroke":true,"locked":false,"zIndex":5,"valid":true,"visible":true,"cover":1,"name":"","transScope":"PRINT&COVER","transPrint":0,"transWhite":0,"matrix":[67.71653543307086,0,696.5353385826771,0,576.771653543307,1863.3857165354316]}|
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
## KiCad design motor_slider/motor_slider.kicad_pcb

Parts:
C1, C4, C21, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33: 100nF; C0603
C2, C3: 20pF; C0603
C5, C10, C13, C16: 2.2uF; C_0805_2012Metric
C6, C8, C9, C11, C14, C17, C19, C20, C22: 10uF; C_0805_2012Metric
C7, C12, C15, C18: 10nF; C0603
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2: Conn_02x02_Odd_Even; PinSocket_2x02_P2.54mm_Vertical
J6: VM; PinSocket_1x01_P2.54mm_Vertical
J7: GND; PinSocket_1x01_P2.54mm_Vertical
J8: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
L1: 3.3R; L_0603_1608Metric
R1: 10k; R0603
R2, R3, R7, R8, R11, R14: 5.1k; R0603
R4: 1M; R0603
R5, R6, R9, R10, R12, R13, R15, R16: 0.1R; R0603
R17, R18, R19, R20, R21, R22, R23, R24: 1k; R0603
SW1: BOOT; 小龟轻触开关3_4_22.0MM
SW2: RESET; 小龟轻触开关3_4_22.0MM
U1, U8, U11, U15: DRV8833PWP; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_The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
U2: MOTOR1; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U3: CH32V203C8T6; LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL; MPN CH32V203C8T6; LCSC Part C3001172
U4, U16: ME6210A33M3G; SOT-23
U5: MOTOR2; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U6: MOTOR3; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U7: MOTOR4; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U9: MOTOR5; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U10: MOTOR6; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U12: MOTOR7; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U13: MOTOR8; CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT; MPN ZX-SH1.0-2PLT; LCSC Part C7430451
U14: POT1; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U17: POT2; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U18: POT3; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U19: POT4; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U20: POT5; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U21: POT6; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U22: SWD; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U23: POT7; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
U24: POT8; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P; MPN ZX-SH1.0-3PLT; LCSC Part C7430452
Y1: 8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C9.2, C31.1, C32.1, C33.1, L1.1, SW1.2, U3.1 (VBAT), U3.24 (VDD_VIO_1), U3.36 (VDD_2), U3.48 (VDD_VIO_3), U4.2 (Vout)
+3.3VA: C20.2, U14.1, U16.2 (Vout), U17.1, U18.1, U19.1, U20.1, U21.1, U23.1, U24.1
+5V: C8.2, C19.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J8.3, U4.3 (VIN), U16.3 (VIN)
/ADC0: C21.1, R17.1, U3.10 (PA0/WKUP/ADC0)
/ADC1: C24.1, R18.1, U3.11 (PA1/ADC1)
/ADC2: C25.1, R19.1, U3.12 (PA2/ADC2)
/ADC3: C26.1, R20.1, U3.13 (PA3/ADC3)
/ADC4: C27.1, R24.1, U3.14 (PA4/ADC4/DAC0)
/ADC5: C28.1, R23.1, U3.15 (PA5/ADC5/DAC1)
/ADC6: C29.1, R22.1, U3.16 (PA6/ADC6)
/ADC7: C30.1, R21.1, U3.17 (PA7/ADC7)
/BOOT0: R1.1, SW1.1, U3.44 (BOOT0)
/OSC_IN: C3.1, U3.5 (OSC_IN/PD0), Y1.3
/OSC_OUT: C2.1, U3.6 (OSC_OUT/PD1), Y1.1
/PB6: J2.1, U3.42 (PB6)
/PB7: J2.3, U3.43 (PB7)
/SWD_CLK: U3.37 (PA14/SWCLK), U22.2
/SWD_DIO: U3.34 (PA13/SWDIO), U22.3
/TIM1_1: U3.29 (PA8), U8.10 (BIN2)
/TIM1_2: U3.30 (PA9), U8.9 (BIN1)
/TIM1_3: U3.31 (PA10), U11.16 (AIN1)
/TIM1_4: U3.32 (PA11/USB1DM), U11.15 (AIN2)
/TIM2_1: U3.38 (PA15), U11.10 (BIN2)
/TIM2_2: U3.39 (PB3), U11.9 (BIN1)
/TIM2_3: U1.10 (BIN2), U3.21 (PB10)
/TIM2_4: U1.9 (BIN1), U3.22 (PB11)
/TIM3_1: U3.40 (PB4), U15.16 (AIN1)
/TIM3_2: U3.41 (PB5), U15.15 (AIN2)
/TIM3_3: U1.16 (AIN1), U3.18 (PB0/ADC8)
/TIM3_4: U1.15 (AIN2), U3.19 (PB1/ADC9)
/TIM4_3: U3.45 (PB8), U15.10 (BIN2)
/TIM4_4: U3.46 (PB9), U15.9 (BIN1)
/USBDN: J1.A7 (D-), J1.B7 (D-), J2.2
/USBDP: J1.A6 (D+), J1.B6 (D+), J2.4
/`TIM4_1: U3.27 (PB14), U8.16 (AIN1)
/`TIM4_2: U3.28 (PB15), U8.15 (AIN2)
/~NRST: C1.1, SW2.2, U3.7 (NRST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.1, C9.1, C10.2, C11.2, C13.2, C14.2, C16.2, C17.2, C19.1, C20.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J7.1 (Pin_1_1), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R9.2, R10.2, R12.2, R13.2, R15.2, R16.2, SW2.1, U1.13 (GND), U1.17 (GND), U3.8 (VSSA), U3.20 (PB2/BOOT1), U3.23 (VSS_1), U3.35 (VSS_2), U3.47 (VSS_3), U4.1 (GND), U8.13 (GND), U8.17 (GND), U11.13 (GND), U11.17 (GND), U14.3, U15.13 (GND), U15.17 (GND), U16.1 (GND), U17.3, U18.3, U19.3, U20.3, U21.3, U22.1, U23.3, U24.3, Y1.2 (G), Y1.4 (G)
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: C4.1, J1.S1 (SHIELD), R4.1
unnamed: J6.1 (Pin_1_1), J8.1
unnamed: R17.2, U14.2
unnamed: R18.2, U17.2
unnamed: R19.2, U18.2
unnamed: R20.2, U19.2
unnamed: R21.2, U24.2
unnamed: R22.2, U23.2
unnamed: R23.2, U21.2
unnamed: R24.2, U20.2
unnamed: R5.1, U1.3 (AISEN)
unnamed: U1.2 (AOUT1), U2.2
unnamed: U1.4 (AOUT2), U2.1
unnamed: R6.1, U1.6 (BISEN)
unnamed: U1.7 (BOUT1), U5.1
unnamed: U1.5 (BOUT2), U5.2
unnamed: C7.1, U1.11 (VCP)
unnamed: C5.1, U1.14 (VINT)
unnamed: R7.1, U1.1 (~SLEEP)
unnamed: C22.1, C23.1, L1.2, U3.9 (VDDA)
unnamed: R9.1, U8.3 (AISEN)
unnamed: U6.2, U8.2 (AOUT1)
unnamed: U6.1, U8.4 (AOUT2)
unnamed: R10.1, U8.6 (BISEN)
unnamed: U7.1, U8.7 (BOUT1)
unnamed: U7.2, U8.5 (BOUT2)
unnamed: C12.1, U8.11 (VCP)
unnamed: C10.1, U8.14 (VINT)
unnamed: R8.1, U8.1 (~SLEEP)
unnamed: R12.1, U11.3 (AISEN)
unnamed: U9.2, U11.2 (AOUT1)
unnamed: U9.1, U11.4 (AOUT2)
unnamed: R13.1, U11.6 (BISEN)
unnamed: U10.1, U11.7 (BOUT1)
unnamed: U10.2, U11.5 (BOUT2)
unnamed: C15.1, U11.11 (VCP)
unnamed: C13.1, U11.14 (VINT)
unnamed: R11.1, U11.1 (~SLEEP)
unnamed: R15.1, U15.3 (AISEN)
unnamed: U12.2, U15.2 (AOUT1)
unnamed: U12.1, U15.4 (AOUT2)
unnamed: R16.1, U15.6 (BISEN)
unnamed: U13.1, U15.7 (BOUT1)
unnamed: U13.2, U15.5 (BOUT2)
unnamed: C18.1, U15.11 (VCP)
unnamed: C16.1, U15.14 (VINT)
unnamed: R14.1, U15.1 (~SLEEP)
Vdrive: C6.1, C7.2, C11.1, C12.2, C14.1, C15.2, C17.1, C18.2, J8.2, R7.2, R8.2, R11.2, R14.2, U1.12 (VM), U8.12 (VM), U11.12 (VM), U15.12 (VM)

Notes on the sheet:
`并不是定时器PWM输出，是普通GPIO

Board: 2 copper layers, 60.0 x 47.0 mm, 90 parts (3 on the bottom side), 88 nets.

File motor_slider/jlcpcb/production_files/BOM-motor_slider.csv:

Comment,Designator,Footprint,LCSC,Quantity
CH32V203C8T6,U3,LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL,C3001172,1
MOTOR1,U2,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR2,U5,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR3,U6,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR4,U7,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR5,U9,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR6,U10,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR7,U12,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
MOTOR8,U13,CONN-SMD_2P-P1.00_MEGASTAR_ZX-SH1.0-2PLT,C7430451,1
POT1,U14,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT2,U17,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT3,U18,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT4,U19,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT5,U20,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT6,U21,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT7,U23,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
POT8,U24,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
SWD,U22,CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P,C7430452,1
100nF,C26,C0603,,1
100nF,C21,C0603,,1
1k,R18,R0603,,1
1k,R24,R0603,,1
1k,R20,R0603,,1
1k,R23,R0603,,1
1k,R21,R0603,,1
1k,R22,R0603,,1
1k,R17,R0603,,1
1k,R19,R0603,,1
100nF,C29,C0603,,1
100nF,C30,C0603,,1
100nF,C24,C0603,,1
DRV8833PWP,U1,HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_ThermalVias,,1
10uF,C9,C_0805_2012Metric,,1
10uF,C6,C_0805_2012Metric,,1
5.1k,R14,R0603,,1
5.1k,R3,R0603,,1
5.1k,R11,R0603,,1
5.1k,R2,R0603,,1
10uF,C14,C_0805_2012Metric,,1
DRV8833PWP,U15,HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_ThermalVias,,1
VM,J6,PinSocket_1x01_P2.54mm_Vertical,,1
0.1R,R12,R0603,,1
10nF,C15,C0603,,1
BOOT,SW1,小龟轻触开关3_4_22.0MM,,1
10uF,C17,C_0805_2012Metric,,1
2.2uF,C5,C_0805_2012Metric,,1
10uF,C20,C_0805_2012Metric,,1
GND,J7,PinSocket_1x01_P2.54mm_Vertical,,1
0.1R,R10,R0603,,1
100nF,C25,C0603,,1
10nF,C7,C0603,,1
0.1R,R13,R0603,,1
5.1k,R7,R0603,,1
20pF,C2,C0603,,1
ME6210A33M3G,U4,SOT-23,,1
ME6210A33M3G,U16,SOT-23,,1
20pF,C3,C0603,,1
10k,R1,R0603,,1
100nF,C27,C0603,,1
0.1R,R5,R0603,,1
DRV8833PWP,U11,HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_ThermalVias,,1
10nF,C12,C0603,,1
0.1R,R6,R0603,,1
2.2uF,C10,C_0805_2012Metric,,1
10uF,C8,C_0805_2012Metric,,1
Conn_02x02_Odd_Even,J2,PinSocket_2x02_P2.54mm_Vertical,,1
0.1R,R9,R0603,,1
100nF,C4,C0603,,1
USB_C_Receptacle_USB2.0_16P,J1,USB_C_Receptacle_G-Switch_GT-USB-7010ASV,,1
DRV8833PWP,U8,HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_ThermalVias,,1
10uF,C11,C_0805_2012Metric,,1
10uF,C19,C_0805_2012Metric,,1
Conn_01x03,J8,PinSocket_1x03_P2.54mm_Vertical,,1
0.1R,R16,R0603,,1
2.2uF,C13,C_0805_2012Metric,,1
10nF,C18,C0603,,1
100nF,C28,C0603,,1
100nF,C33,C0603,,1
100nF,C32,C0603,,1
100nF,C1,C0603,,1
100nF,C31,C0603,,1
2.2uF,C16,C_0805_2012Metric,,1
RESET,SW2,小龟轻触开关3_4_22.0MM,,1
1M,R4,R0603,,1
0.1R,R15,R0603,,1
8M,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,,1
5.1k,R8,R0603,,1
10uF,C22,C_0805_2012Metric,,1
100nF,C23,C0603,,1
3.3R,L1,L_0603_1608Metric,,1

## Code that names these connections

File CH32V203C8T/User/bsp/motor_hw.c (part):

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
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_TIM1 | RCC_APB2Periph_GPIOA | RCC_APB2Periph_GPIOB, ENABLE);

    /* === TIM1: 电机 4 (CH2=PA9/A, CH1=PA8/B), 电机 5 (CH3=PA10/A, CH4=PA11/B) === */
    gpio.GPIO_Pin = GPIO_Pin_8 | GPIO_Pin_9 | GPIO_Pin_10 | GPIO_Pin_11;
    gpio.GPIO_Mode = GPIO_Mode_AF_PP;
    gpio.GPIO_Speed = GPIO_Speed_50MHz;
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    oc.TIM_OCIdleState = TIM_OCIdleState_Reset;
    oc.TIM_OCNIdleState = TIM_OCNIdleState_Reset;

    TIM_OC1Init(TIM1, &oc); /* CH1=PA8  — 电机4 B */
    TIM_OC2Init(TIM1, &oc); /* CH2=PA9  — 电机4 A */
    TIM_OC3Init(TIM1, &oc); /* CH3=PA10 — 电机5 A */
    TIM_OC4Init(TIM1, &oc); /* CH4=PA11 — 电机5 B */

    TIM_CtrlPWMOutputs(TIM1, ENABLE);
    TIM_Cmd(TIM1, ENABLE);

    /* === TIM2: 电机 6 (CH1=PA15/A, CH2=PB3/B), 电机 2 (CH3=PB10/B, CH4=PB11/A) === */
    RCC_APB1PeriphClockCmd(RCC_APB1Periph_TIM2, ENABLE);
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_AFIO | RCC_APB2Periph_GPIOA | RCC_APB2Periph_GPIOB, ENABLE);

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    oc.TIM_Pulse = 0;
    oc.TIM_OCPolarity = TIM_OCPolarity_High;

    TIM_OC1Init(TIM2, &oc); /* PA15 — 电机6 A */
    TIM_OC2Init(TIM2, &oc); /* PB3  — 电机6 B */
    TIM_OC3Init(TIM2, &oc); /* PB10 — 电机2 B */
    TIM_OC4Init(TIM2, &oc); /* PB11 — 电机2 A */

    TIM_Cmd(TIM2, ENABLE);

    /* === TIM3: 电机 7 (CH1=PB4/A, CH2=PB5/B), 电机 1 (CH3=PB0/A, CH4=PB1/B) === */
    RCC_APB1PeriphClockCmd(RCC_APB1Periph_TIM3, ENABLE);

    gpio.GPIO_Pin = GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_4 | GPIO_Pin_5;
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    oc.TIM_Pulse = 0;
    oc.TIM_OCPolarity = TIM_OCPolarity_High;

    TIM_OC1Init(TIM3, &oc); /* PB4 — 电机7 A */
    TIM_OC2Init(TIM3, &oc); /* PB5 — 电机7 B */
    TIM_OC3Init(TIM3, &oc); /* PB0 — 电机1 A */
    TIM_OC4Init(TIM3, &oc); /* PB1 — 电机1 B */

    TIM_Cmd(TIM3, ENABLE);

    /* === TIM4: 电机 8 (CH3=PB8/A, CH4=PB9/B) === */
    RCC_APB1PeriphClockCmd(RCC_APB1Periph_TIM4, ENABLE);

    gpio.GPIO_Pin = GPIO_Pin_8 | GPIO_Pin_9;
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    oc.TIM_Pulse = 0;
    oc.TIM_OCPolarity = TIM_OCPolarity_High;

    TIM_OC3Init(TIM4, &oc); /* PB8 — 电机8 A */
    TIM_OC4Init(TIM4, &oc); /* PB9 — 电机8 B */

    TIM_Cmd(TIM4, ENABLE);

    /* === 电机 3: GPIO PB14, PB15 === */
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOB, ENABLE);
    gpio.GPIO_Pin = GPIO_Pin_14 | GPIO_Pin_15;
    gpio.GPIO_Mode = GPIO_Mode_Out_PP;
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    RCC_APB2PeriphClockCmd(RCC_APB2Periph_ADC1 | RCC_APB2Periph_GPIOA, ENABLE);
    RCC_AHBPeriphClockCmd(RCC_AHBPeriph_DMA1, ENABLE);

    /* PA0~PA7 模拟输入 */
    gpio.GPIO_Pin =
        GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_2 | GPIO_Pin_3 | GPIO_Pin_4 | GPIO_Pin_5 | GPIO_Pin_6 | GPIO_Pin_7;
    gpio.GPIO_Mode = GPIO_Mode_AIN;
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            TIM_SetCompare2(TIM1, (dir == kMotorDir_Forward || dir == kMotorDir_Brake) ? duty : 0);
            TIM_SetCompare1(TIM1, (dir == kMotorDir_Reverse || dir == kMotorDir_Brake) ? duty : 0);
            break;
        case kMotorIdx_5: /* GPIO PB14=IN1, PB15=IN2 */
            _Motor5SetPdm(dir, duty);
            break;
        case kMotorIdx_6: /* TIM2 CH4=IN1, CH3=IN2 */
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
## Commit log

2026-06-11 usb hid printf
2026-06-12 kfifo改为柔性数组实现
2026-06-12 feat：实现 HID1 接口用于电机控制，并与现有 USB 功能集成
    - 添加了用于电机控制的 HID1 报告缓冲区和命令处理。
    - 更新了 USB 端点初始化，以包含用于 IN/OUT 通信的 HID1。
    - 创建了电机控制架构，集成了 PWM 和 ADC。
    - 实现了闭环电机位置控制的 PID 控制逻辑。
    - 提升了电机控制系统和 USB 通信的文档。
    - 添加了用于电机和 PID 控制逻辑的新文件，包括 ADC 和 DMA 设置。
2026-06-12 规范化代码
2026-06-12 hid和上位机工作
2026-06-12 重构上位机界面
2026-06-12 让上位机真的可以控制
2026-06-12 添加上位机PID控制，clang-format文件
2026-06-13 refactor: 更新电机设置协议
2026-06-13 fix: 2/3/4通道方向反向
2026-06-14 fix: 修复上位机控制电机时实际控制的是反向序号的电机
2026-06-14 refactor: 更新硬件pcb
2026-06-15 refactor: 重新整理所有文件
2026-06-15 fix: pwm在adc前初始化避免意外的adc不工作
2026-06-15 refactor: 将pid的输出从[0,1000)修改为800+[0,200)
2026-06-17 feat: add PWM control functionality to HID ADC monitor
    - Introduced new methods in HidWorker for sending PWM bias and max values via HID1 OUT.
    - Added UI elements in MainWindow for PWM Bias and Max settings, including spin boxes and send buttons.
    - Implemented signal-slot connections for the new PWM controls to handle user input and send commands.
2026-06-17 feat: 添加 MIDI 控制的 ADC 滤波和确认机制
2026-06-17 refactor: HID printf无需中断干预
2026-06-17 refactor: systick计时器
2026-06-17 chore: 电机控制注释
2026-06-17 refactor: midi cc 转换器
2026-06-17 chore: 删除kicad备份文件夹，修改文档
2026-06-17 chore: 更新readme
2026-06-17 chore: 重新整理代码块
2026-06-18 feat: 使用TIM+DMA写GPIO的形式给电机5提供PWM
2026-06-22 refactor: midi tx/rx 使用时间gap阻止误触发 midi直接使用电机控制器的数据滤波器
